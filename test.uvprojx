# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf --elf -o "$L@L.elf" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Libraries;.\FreeRTOS;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\src;.\System;.\Hardware;.\DebugTool;.\Task;.\Task\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ./Libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Hardware
    ./Hardware/: BlueTooth.c BlueTooth.h Encoder.c Encoder.h Key.c Key.h KeyEXIT.c KeyEXIT.h Motor.c Motor.h MPU6050.c MPU6050.h MPU6050_Reg.h NRF24L01.c NRF24L01.h NRF24L01_Define.h OLED.c OLED.h OLED_Matrix.c OLED_Matrix.h PWM.c PWM.h Serial.c Serial.h LED.c LED.h
  group System
    ./System/: delay.c delay.h RunTick.c RunTick.h MyI2C.c MyI2C.h MyRTC.c MyRTC.h Timer.c Timer.h
  group Task
    ./Task/: Task_Init.c Task_Key_Scan.c Task_Config.h Task_Hardware_Init.c Task_OLED.c Task_MPU6050.c Task_Motor_Control.c Task_BlueTooth.c Task_Encoder.c Task_Run.c Task_Debug.c Task_PID.c Task_NRF24L001.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOS_Demo.c FreeRTOS_Demo.h PID.c PID.h
  group DebugTool
    ./DebugTool/: Debugconfig.h Tool.c Tool.h
  group FreeRTOS\inc
    ./FreeRTOS/: FreeRTOSConfig.h
    ./FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS\port
    ./FreeRTOS/port/: heap_4.c port.c
  group FreeRTOS\src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Task\include
    ./Task/include/: Task_BlueTooth.h Task_Encoder.h Task_Hardware_Init.h Task_Init.h Task_Key_Scan.h Task_Motor_Control.h Task_MPU6050.h Task_OLED.h Task_Run.h Task_Debug.h Task_PID.h Task_NRF24L01.h
